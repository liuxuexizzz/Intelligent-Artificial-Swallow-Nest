# Keil uVision project atk_f103.uvprojx, settings and files
target ATK-MO1218 (ARM-ADS)
  device: APM32F103C8 APEXMIC
  pack: APEXMIC.APM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../START/: startup_stm32f10x_md.s
  group User
    ../../User/: main.c stm32f1xx_it.c demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/DHT11/: dht11.c dht11.h
    ../../Drivers/BSP/BH1750/: BH1750.c BH1750.h
    ../../Drivers/BSP/ESP8266/: atk_mw8266d.c atk_mw8266d.h atk_mw8266d_uart.c atk_mw8266d_uart.h
  group Readme
    ../../: readme.txt
